# Keil uVision project mimasuo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: mimasuo +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51
    ../source/: delay.c LCD1602.C mimasuo.c RFID.c SPI.c main.c AT24C02PZ.c duoji.c SYN6288.c
  group headfiles
    ../source/: config.h delay.h LCD1602.h RFID.h SPI.h mimasuo.h MAIN.h AT24C02PZ.h duoji.h SYN6288.h
